# Keil uVision project ble.uvprojx, settings and files
target Release (6180000::V6.18::ARMCLANG)
  device: BlueNRG-345 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.3.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ble
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER CONFIG_DEVICE_BLUENRG_LP CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL BLE_STACK_BASIC_CONF CONFIG_DEVICE_BLUENRG_345
  c include: .\User\Inc;.\Peripherals_Drivers\Inc;.\Middlewares\HAL\Inc;.\Middlewares\PKAMGR\Inc;.\Middlewares\RNGMGR\Inc;.\Middlewares\AESMGR\Inc;.\Middlewares\BLECNTR\Inc;.\Middlewares\Bluetooth_LE\inc;.\Middlewares\NVMDB\Inc;.\Middlewares\FreeRTOS\BlueNRG;.\Middlewares\cryptolib\Inc;.\Middlewares\cryptolib\Inc\Common;.\Middlewares\cryptolib\Inc\AES;.\Middlewares\BLE_Application\Profiles\Inc;.\Middlewares\BLE_Application\layers_inc
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\BlueNRG_LP.sct
  link misc: --predefine="-DCONFIG_DEVICE_BLUENRG_345=1"
  group User
    ./User/Src/: main.c rf_device_it.c gatt_db.c
    ./: FreeRTOS_handlers.c
  group Middlewares/AESMGR
    ./MIddlewares/AESMGR/Src/: aes_manager_bluenrg_lp.c
  group Middlewares/RNGMGR
    ./MIddlewares/RNGMGR/Src/: rng_manager.c rng_manager_bluenrg_lp.c
  group Middlewares/NVMDB
    ./MIddlewares/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/HAL
    ./MIddlewares/HAL/Src/: fifo.c hal_miscutil.c miscutil.c osal.c
    ./Middlewares/HAL/Src/: blue_unit_conversion.s context_switch.s osal_memcpy.s
  group Middlewares/PKAMGR
    ./Middlewares/PKAMGR/Src/: pka_manager.c pka_manager_bluenrg_lp.c
  group Middlewares/Cryptolib
    ./Middlewares/cryptolib/: aes_hw.c libcrypto.a
  group Middlewares/BLECNTR
    ./Middlewares/BLECNTR/Src/: ble_controller.c ble_controller_bluenrg_lp.c
  group Middlewares/BluetoothLE
    ./Middlewares/Bluetooth_LE/library/: libbluenrg_lp_stack.a
    ./Middlewares/Bluetooth_LE/src/: stack_user_cfg.c stack_cns_api_stubs.c
  group Middleware/BLE/Profile
    ./Middlewares/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Drivers/Peripherals
    ./Peripherals_Drivers/Src/: rf_driver_hal_power_manager.c rf_driver_hal_vtimer.c rf_driver_ll_adc.c rf_driver_ll_crc.c rf_driver_ll_dma.c rf_driver_ll_exti.c rf_driver_ll_flash.c rf_driver_ll_gpio.c rf_driver_ll_i2c.c rf_driver_ll_lpuart.c rf_driver_ll_pwr.c rf_driver_ll_radio_2g4.c rf_driver_ll_rcc.c rf_driver_ll_rng.c rf_driver_ll_rtc.c rf_driver_ll_spi.c rf_driver_ll_tim.c rf_driver_ll_timer.c rf_driver_ll_usart.c rf_driver_ll_utils.c rf_driver_ll_pka_v7b.c
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Heap 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.6.0, Device:Startup 1.0.0
